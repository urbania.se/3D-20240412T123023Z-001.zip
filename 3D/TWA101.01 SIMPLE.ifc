Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: TWA101.01 SIMPLE.ifc
Time: 2023-08-09T14:09:40
Author: Oskar
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (76)
Name | L006.07-00.001_Domyòlna<Obrobiona>, Description | L006.07-00.001_Domyòlna<Obrobiona>, ObjectType
44 x  | L006.07-00.001_Domyòlna<Obrobiona>:1 | SketchupComponentInstance
2 x  | L006.07-00.002_Domyòlna<Obrobiona> - Description: L006.07-00.002_Domyòlna<Obrobiona>:1; ObjectType: SketchupComponentInstance
2 x  | L006.07-01.000_Domyòlna<Obrobiona> - Description: L006.07-01.000_Domyòlna<Obrobiona>:1; ObjectType: SketchupComponentInstance
2 x  | LustroL006.05-01.000_Domyòlna<Obrobiona> - Description: LustroL006.05-01.000_Domyòlna<Obrobiona>:1; ObjectType: SketchupComponentInstance
2 x  | TWA001.00.01.01 - Description: TWA001.00.01.01:1; ObjectType: SketchupComponentInstance
2 x  | TWA001.00.01.02 - Description: TWA001.00.01.02:1; ObjectType: SketchupComponentInstance
2 x  | TWA001.00.01.03 - Description: TWA001.00.01.03:1; ObjectType: SketchupComponentInstance
2 x  | TWA001.00.01.04 - Description: TWA001.00.01.04:1; ObjectType: SketchupComponentInstance
17 x  | TWA001.00.03.01_Domyòlna<Obrobiona> - Description: TWA001.00.03.01_Domyòlna<Obrobiona>:1; ObjectType: SketchupComponentInstance
 | TWA001.00.02.01 - Description: TWA001.00.02.01:1; ObjectType: SketchupComponentInstance
